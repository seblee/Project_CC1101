# Keil uVision project Project_CC1101.uvprojx, settings and files
target Project_CC1101 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_CC1101 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source_File\app\inc;.\Source_File\drv_mcu\inc;.\Source_File\drv_periph\inc;.\Source_File\Std_lib\inc;.\Source_File\Std_lib\startup
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./Source_File/app/src/: main.c
  group drv_periph
    ./Source_File/drv_periph/src/: drv_CC1101.c
  group drv_mcu
    ./Source_File/drv_mcu/src/: drv_button.c drv_delay.c drv_led.c drv_spi.c drv_uart.c
  group std_lib
    ./Source_File/Std_lib/src/: core_cm3.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c
    ./Source_File/Std_lib/startup/: startup_stm32f10x_hd.s
